Commit message: end

File: mrl_robots_description/mesh/stingbot.urdf (robot description, URDF)
Before this commit: robot stingbot, 5 links, 4 joints
Links:
- link base_link: geometry 
